# Keil uVision project TSOP.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSOP
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx, USE_STDPERIPH_DRIVER,  HSE_VALUE = 8000000, USE_HSE
  c include: .\support_pacage;.\support_pacage\arm;.\support_pacage\gcc\linker;.\support_pacage\gcc;.\support_pacage\inc;.\src;.\src\time_service;.\src\usart2;.\src\usart3;.\src\usart1;.\src\adc;.\src\Motor;.\src\Pin;.\src\dma;.\src\PWM;.\src\IMU_SPI;.\src\main;.\src\external;.\src\SPI_DOT;.\src\SPI_1;.\src\usable;.\src\mpu9250;.\src\global_macros;.\src\omniplatform;.\src\IMU_USART;.\src\spl4;.\src\spl4\inc;.\src\spl4\src;.\src\cmsis;.\src\usart6;.\src\OpenMV;.\src\TSOP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group time_service
    ./src/time_service/: time_service.cpp time_service.h
  group usart2
    ./src/usart2/: usart2.cpp usart2.h
  group adc
    ./src/adc/: adc.cpp adc.h
  group Pin
    ./src/Pin/: Pin.cpp Pin.h
  group Motor
    ./src/Motor/: Motor.cpp Motor.h
  group dma
    ./src/dma/: dma.cpp dma.h
  group IMU_SPI
    ./src/IMU_SPI/: IMU_SPI.cpp IMU_SPI.h
  group main
    ./src/main/: main.cpp project_config.h RTE_Device.h
  group external
    ./src/external/: retarget.cpp
  group SPI_DOT
    ./src/SPI_DOT/: SPI_DOT.cpp SPI_DOT.h
  group SPI_1
    ./src/SPI_1/: SPI_1.cpp SPI_1.h
  group usable
    ./src/usable/: usable.h
  group mpu9250
    ./src/mpu9250/: mpu9250_registers_spi.h mpu9250_spi.cpp mpu9250_spi.h
  group global_macros
    ./src/global_macros/: global_macros.h
  group omniplatform
    ./src/omniplatform/: omniplatform.h omniplatform.cpp
  group IMU_USART
    ./src/IMU_USART/: IMU_USART.h IMU_USART.cpp
  group usart3
    ./src/usart3/: usart3.h usart3.cpp
  group usart1
    ./src/usart1/: usart1.h usart1.cpp
  group spl4
    ./src/spl4/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./src/spl4/: stm32f4xx_conf.h
  group usart6
    ./src/usart6/: usart6.h usart6.cpp
  group OpenMV
    ./src/OpenMV/: OpenMV.cpp OpenMV.h
  group TSOP
    ./src/TSOP/: TSOP.cpp TSOP.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
