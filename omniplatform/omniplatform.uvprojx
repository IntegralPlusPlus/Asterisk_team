# Keil uVision project omniplatform.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: omniplatform
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER, HSE_VALUE = 8000000, USE_HSE
  c include: .\spl;.\spl\inc;.\spl\src;.\support_pacage;.\support_pacage\arm;.\support_pacage\gcc\linker;.\support_pacage\gcc;.\support_pacage\inc;.\src;.\src\time_service;.\src\usart2;.\src\adc;.\src\Motor;.\src\Pin;.\src\dma;.\src\PWM;.\src\IMU_SPI;.\src\main;.\src\external;.\src\SPI_DOT;.\src\SPI_1;.\src\usable;.\src\mpu9250;.\src\global_macros
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./spl/: stm32f4xx.h stm32f4xx_conf.h
  group time_service
    ./src/time_service/: time_service.cpp time_service.h
  group usart2
    ./src/usart2/: usart2.cpp usart2.h
  group adc
    ./src/adc/: adc.cpp adc.h
  group Pin
    ./src/Pin/: Pin.cpp Pin.h
  group Motor
    ./src/Motor/: Motor.cpp Motor.h
  group dma
    ./src/dma/: dma.cpp dma.h
  group PWM
    ./src/PWM/: PWM.h
  group IMU_SPI
    ./src/IMU_SPI/: IMU_SPI.cpp IMU_SPI.h
  group main
    ./src/main/: main.cpp project_config.h RTE_Device.h
  group external
    ./src/external/: retarget.cpp
  group SPI_DOT
    ./src/SPI_DOT/: SPI_DOT.cpp SPI_DOT.h
  group SPI_1
    ./src/SPI_1/: SPI_1.cpp SPI_1.h
  group usable
    ./src/usable/: usable.h
  group mpu9250
    ./src/mpu9250/: mpu9250_registers_spi.h mpu9250_spi.cpp mpu9250_spi.h
  group global_macros
    ./src/global_macros/: global_macros.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
